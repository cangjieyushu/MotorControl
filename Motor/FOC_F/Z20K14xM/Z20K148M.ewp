# IAR project Z20K148M.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Z20K148M ZhiXin Z20K148M
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEV_Z20K148M
  ICCARM.CCIncludePath2: ..\..\0_SDK\DEVICE\Z20K14xM; ..\..\0_SDK\DEVICE\Z20K14xM\Z20K148M\Inc; ..\..\0_SDK\STD\Z20K14xM\inc; ..\..\2_COMMON\CMU; ..\..\2_COMMON\MATH; ..\..\2_COMMON\RTT; ..\3_MOTOR; ..\4_SYSTASK; 1_HARDWARE\BSP; 1_HARDWARE\MCHAL; 5_MAIN; ..\..\0_SDK\STD\Z20A8300A\inc; 1_HARDWARE\Z20A8300A
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Z20K148M.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\0_SDK\DEVICE\Z20K14xM\Z20K148M\MakeRule\IAR\Z20K148M_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group 0_SDK/DEVICE
    ../../0_SDK/DEVICE/Z20K14xM/: device_regs.h platform_cfg.h
    ../../0_SDK/DEVICE/Z20K14xM/Z20K148M/Inc/: Z20K148M.h
    ../../0_SDK/DEVICE/Z20K14xM/Z20K148M/Startup/IAR/: Z20K148M_startup.s
  group 0_SDK/STD
    ../../0_SDK/STD/Z20K14xM/src/: adc_drv.c aes_drv.c can_drv.c clock_drv.c cmp_drv.c cmu_drv.c common_drv.c crc_drv.c dma_drv.c eiru_drv.c ewdt_drv.c flash_drv.c gpio_drv.c i2c_drv.c i2s_drv.c int_drv.c mcpwm_drv.c pmu_drv.c regfile_drv.c rtc_drv.c scm_drv.c seru_drv.c smpu_drv.c spi_drv.c srmc_drv.c stim_drv.c sysctrl_drv.c tdg_drv.c tim_drv.c tmu_drv.c trng_drv.c uart_drv.c wdog_drv.c
  group 0_SDK/Z20A8300A
    ../../0_SDK/STD/Z20A8300A/src/: Z20A8300A_Config.c Z20A8300A_Ctrl.c Z20A8300A_Diag.c Z20A8300A_Spi.c
  group 1_HARDWARE/BSP
    1_HARDWARE/BSP/: BSP.h BSP_ADC.c BSP_ADC.h BSP_CLK.c BSP_CLK.h BSP_DMA.c BSP_DMA.h BSP_GPIO.c BSP_GPIO.h BSP_ISR.c BSP_ISR.h BSP_PWM.c BSP_PWM.h BSP_TIM.c BSP_TIM.h BSP_TMU.c BSP_TMU.h BSP_USART.c BSP_USART.h BSP_WDG.c BSP_WDG.h
  group 1_HARDWARE/MCHAL
    1_HARDWARE/MCHAL/: MotorHal.c MotorHal.h MotorHal_cfg.h
  group 1_HARDWARE/Z20A8300A
    1_HARDWARE/Z20A8300A/: Z20A8300A_Hal.c Z20A8300A_Hal.h Z20A8300A_Init.c Z20A8300A_Init.h
  group 2_COMMON/CMU
    ../../2_COMMON/CMU/: USART.c USART.h
  group 2_COMMON/MATH
    ../../2_COMMON/MATH/: Math.c Math.h Matrix.c Matrix.h
  group 2_COMMON/RTT
    ../../2_COMMON/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group 3_MOTOR
    ../3_MOTOR/: MotorDent.c MotorDent.h MotorEst.c MotorEst.h MotorFoc.c MotorFoc.h MotorPara.c MotorPara.h MotorTask.c MotorTask.h PmsmPara.h
  group 4_SYSTASK
    ../4_SYSTASK/: Button.c Button.h Current.c Current.h Error.c Error.h Speed.c Speed.h SysTask.c SysTask.h Temperature.c Temperature.h Voltage.c Voltage.h
  group 5_MAIN
    5_MAIN/: Main.c Main.h
