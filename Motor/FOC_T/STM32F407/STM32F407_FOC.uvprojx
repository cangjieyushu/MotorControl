# Keil uVision project STM32F407_FOC.uvprojx, settings and files
target STM32F407_FOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_FOC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__CC_ARM
  c include: ..\..\0_SDK\DEVICE\STM32F4\Core;..\..\0_SDK\DEVICE\STM32F4\STM32F407\INC;..\..\0_SDK\DEVICE\STM32F4\STM32F407\STARTUP\KEIL;..\..\0_SDK\DEVICE\STM32F4;..\..\0_SDK\STD\STM32F4\inc;.\1_HARDWARE\BSP;.\1_HARDWARE\MCHAL;..\..\2_COMMON\CMU;..\..\2_COMMON\MATH;..\..\2_COMMON\RTT;..\..\4_SYSTASK;..\3_MOTOR;.\5_MAIN
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 0_SDK_DEVICE
    ../../0_SDK/DEVICE/STM32F4/STM32F407/STARTUP/KEIL/: startup_stm32f40_41xxx.s
    ../../0_SDK/DEVICE/STM32F4/STM32F407/INC/: stm32f4xx.h
    ../../0_SDK/DEVICE/STM32F4/: stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group 0_SDK_STD
    ../../0_SDK/STD/STM32F4/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group 1_HARDWARE_BSP
    ./1_HARDWARE/BSP/: BSP.h BSP_ADC.c BSP_ADC.h BSP_CLK.c BSP_CLK.h BSP_GPIO.c BSP_GPIO.h BSP_ISR.c BSP_ISR.h BSP_PWM.c BSP_PWM.h BSP_TIM.c BSP_TIM.h BSP_USART.c BSP_USART.h BSP_WDG.c BSP_WDG.h
  group 1_HARDWARE_MCHAL
    ./1_HARDWARE/MCHAL/: MotorHal.h MotorHal_cfg.h
  group 2_COMMON
    ../../2_COMMON/MATH/: Math.c Math.h Matrix.c Matrix.h PmsmPara.h
    ../../2_COMMON/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
    ../../2_COMMON/CMU/: USART.c USART.h
  group 3_MOTOR
    ../3_MOTOR/: MotorDent.c MotorDent.h MotorEst.c MotorEst.h MotorFoc.c MotorFoc.h MotorPara.c MotorPara.h MotorState.c MotorState.h MotorTask.c MotorTask.h
  group 4_SYSTASK
    ../../4_SYSTASK/: Button.c Button.h Current.c Current.h Error.c Error.h Speed.c Speed.h SYS.h SysTask.c SysTask.h Temperature.c Temperature.h Voltage.c Voltage.h
  group 5_MAIN
    ./5_MAIN/: Main.c Main.h
