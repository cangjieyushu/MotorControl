# Keil uVision project RS32H6_SQ.uvprojx, settings and files
target RS32H6_SQ (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: RX32H6 ICORE
  pack: Keil.RX32H6_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RS32H6_SQ +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\0_SDK\CORE;..\..\0_SDK\DEVICE\RX32H6\RX32H6\INC;..\..\0_SDK\DEVICE\RX32H6\RX32H6\STARTUP\KEIL;..\..\0_SDK\DEVICE\RX32H6;..\..\0_SDK\STD\RS32H6\inc;.\1_HARDWARE\BSP;.\1_HARDWARE\MCHAL;..\..\2_COMMON\CMU;..\..\2_COMMON\MATH;..\..\2_COMMON\RTT;..\3_MOTOR;..\4_SYSTASK;.\5_MAIN
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group 0_SDK_DEVICE
    ../../0_SDK/DEVICE/RX32H6/: system_rx32h6xx.c system_rx32h6xx.h
    ../../0_SDK/DEVICE/RX32H6/RX32H6/INC/: rx32h6xx.h
    ../../0_SDK/DEVICE/RX32H6/RX32H6/STARTUP/KEIL/: startup_rx32h6xx.s
  group 0_SDK_STD
    ../../0_SDK/STD/RS32H6/src/: rx32h6xx_adc.c rx32h6xx_cmp.c rx32h6xx_crc.c rx32h6xx_exti.c rx32h6xx_flash.c rx32h6xx_gpio.c rx32h6xx_i2c.c rx32h6xx_iwdg.c rx32h6xx_me.c rx32h6xx_opamp.c rx32h6xx_pwr.c rx32h6xx_rcc.c rx32h6xx_rtc.c rx32h6xx_spi.c rx32h6xx_tim.c rx32h6xx_usart.c
  group 1_HARDWARE_BSP
    ./1_HARDWARE/BSP/: BSP_ADC.c BSP_ADC.h BSP_CLK.c BSP_CLK.h BSP_CMP.c BSP_CMP.h BSP_GPIO.c BSP_GPIO.h BSP_ISR.c BSP_ISR.h BSP_OPA.c BSP_OPA.h BSP_PWM.c BSP_PWM.h BSP_TIM.c BSP_TIM.h BSP_USART.c BSP_USART.h BSP_WDG.c BSP_WDG.h
  group 1_HARDWARE_MCHAL
    ./1_HARDWARE/MCHAL/: MotorHal.h MotorHal_cfg.h
  group 2_COMMON
    ../../2_COMMON/MATH/: Math.c Math.h Matrix.c Matrix.h
    ../../2_COMMON/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
    ../../2_COMMON/CMU/: USART.c USART.h
  group 3_MOTOR
    ../3_MOTOR/: MotorEst.c MotorEst.h MotorFoc.c MotorFoc.h MotorPara.c MotorPara.h MotorTask.c MotorTask.h PmsmPara.h
  group 4_SYSTASK
    ../4_SYSTASK/: SysTask.c SysTask.h Button.c Button.h Current.c Current.h Voltage.c Voltage.h Error.c Error.h Speed.c Speed.h Temperature.c Temperature.h
  group 5_MAIN
    ./5_MAIN/: Main.c Main.h
