# IAR project Z20K11xMC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Z20K118M ZhiXin Z20K118M
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEV_Z20K118M
  ICCARM.CCIncludePath2: ..\..\0_SDK\DEVICE\Z20K11xMC; ..\..\0_SDK\DEVICE\Z20K11xMC\Core; ..\..\0_SDK\DEVICE\Z20K11xMC\Z20K118M\Inc; ..\..\0_SDK\STD\Z20K11xMC\inc; ..\..\2_COMMON\CMU; ..\..\2_COMMON\MATH; ..\..\2_COMMON\RTT; ..\3_MOTOR; ..\4_SYSTASK; 1_HARDWARE\BSP; 1_HARDWARE\MCHAL; 5_MAIN; ..\..\0_SDK\STD\Z20A8300A\inc; 1_HARDWARE\Z20A8300A
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Z20K11xMC.srec
  ILINK.IlinkOutputFile: Z20K11xMC.out
  ILINK.IlinkIcfFile: ..\..\0_SDK\DEVICE\Z20K11xMC\Z20K118M\MakeRule\IAR\Z20K118M_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group 0_SDK/DEVICE
    ../../0_SDK/DEVICE/Z20K11xMC/: device_regs.h Z20K11xM_cfg.h Z20K11xM_corecfg.h
    ../../0_SDK/DEVICE/Z20K11xMC/Z20K118M/Inc/: Z20K118M.h
    ../../0_SDK/DEVICE/Z20K11xMC/Z20K118M/Startup/IAR/: Z20K118M_startup.s
  group 0_SDK/STD
    ../../0_SDK/STD/Z20K11xMC/Src/: Z20K11xM_adc.c Z20K11xM_can.c Z20K11xM_clock.c Z20K11xM_cmp.c Z20K11xM_crc.c Z20K11xM_dma.c Z20K11xM_drv.c Z20K11xM_ewdt.c Z20K11xM_flash.c Z20K11xM_gpio.c Z20K11xM_hwdiv.c Z20K11xM_i2c.c Z20K11xM_pmu.c Z20K11xM_regfile.c Z20K11xM_rtc.c Z20K11xM_spi.c Z20K11xM_srmc.c Z20K11xM_stim.c Z20K11xM_sysctrl.c Z20K11xM_tdg.c Z20K11xM_tim.c Z20K11xM_tmu.c Z20K11xM_uart.c Z20K11xM_wdog.c
  group 0_SDK/Z20A8300A
    ../../0_SDK/STD/Z20A8300A/src/: Z20A8300A_Config.c Z20A8300A_Ctrl.c Z20A8300A_Diag.c Z20A8300A_Spi.c
  group 1_HARDWARE/BSP
    1_HARDWARE/BSP/: BSP.h BSP_ADC.c BSP_ADC.h BSP_CLK.c BSP_CLK.h BSP_DMA.c BSP_DMA.h BSP_GPIO.c BSP_GPIO.h BSP_ISR.c BSP_ISR.h BSP_PWM.c BSP_PWM.h BSP_TIM.c BSP_TIM.h BSP_TMU.c BSP_TMU.h BSP_USART.c BSP_USART.h BSP_WDG.c BSP_WDG.h
  group 1_HARDWARE/MCHAL
    1_HARDWARE/MCHAL/: MotorHal.h MotorHal_cfg.h
  group 1_HARDWARE/Z20A8300A
    1_HARDWARE/Z20A8300A/: Z20A8300A_Hal.c Z20A8300A_Hal.h Z20A8300A_Init.c Z20A8300A_Init.h
  group 2_COMMON/CMU
    ../../2_COMMON/CMU/: USART.c USART.h
  group 2_COMMON/MATH
    ../../2_COMMON/MATH/: Math.c Math.h Matrix.c Matrix.h
  group 2_COMMON/RTT
    ../../2_COMMON/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group 3_MOTOR
    ../3_MOTOR/: MotorEst.c MotorEst.h MotorFoc.c MotorFoc.h MotorPara.c MotorPara.h MotorSQ.c MotorSQ.h MotorTask.c MotorTask.h PmsmPara.h
  group 4_SYSTASK
    ../4_SYSTASK/: Button.c Button.h Current.c Current.h Error.c Error.h Speed.c Speed.h SYS.h SysTask.c SysTask.h Temperature.c Temperature.h Voltage.c Voltage.h
  group 5_MAIN
    5_MAIN/: Main.c Main.h
