<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Z20K11xMC.ewp</path>
    </project>
    <batchBuild />
</workspace>
