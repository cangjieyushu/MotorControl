<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Z20M1343L.ewp</path>
    </project>
    <batchBuild />
</workspace>
