# IAR project Z20M1343L.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Z20M1343L ZhiXin Z20M1343L
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEV_Z20M1343L
  ICCARM.CCIncludePath2: ..\..\0_SDK\CORE; ..\..\0_SDK\DEVICE\Z20M1343L; ..\..\0_SDK\DEVICE\Z20M1343L\Z20M1343L\Inc; ..\..\0_SDK\STD\Z20M1343L\Inc; ..\..\2_COMMON\CMU; ..\..\2_COMMON\MATH; ..\..\2_COMMON\RTT; ..\3_MOTOR; ..\4_SYSTASK; 1_HARDWARE\BSP; 1_HARDWARE\MCHAL; 5_MAIN
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Z20M1343L.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\0_SDK\DEVICE\Z20M1343L\Z20M1343L\MakeRule\IAR\Z20M1343L_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group 0_SDK/DEVICE
    ../../0_SDK/DEVICE/Z20M1343L/: Device_Regs.h Platform_Cfg.h Platform_Types.h
    ../../0_SDK/DEVICE/Z20M1343L/Z20M1343L/Inc/: Z20M1343L.h
    ../../0_SDK/DEVICE/Z20M1343L/Z20M1343L/Startup/IAR/: Z20M1343L_Startup.s
  group 0_SDK/STD
    ../../0_SDK/STD/Z20M1343L/Src/: Adc_Drv.c Clk_Drv.c Cmp_Drv.c Cmu_Drv.c Common_Drv.c Crc_Drv.c Ctimer_Drv.c Dma_Drv.c Flash_Drv.c Gdu_Drv.c Gpio_Drv.c Hwacc_Drv.c Int_Drv.c Linphy_Drv.c Mcpwm_Drv.c Pmu_Drv.c Scm_Drv.c Spi_Drv.c Srmc_Drv.c Stim_Drv.c Tdg_Drv.c Uart_Drv.c Wdog_Drv.c
  group 1_HARDWARE/BSP
    1_HARDWARE/BSP/: BSP.h BSP_ADC.c BSP_ADC.h BSP_CLK.c BSP_CLK.h BSP_CMP.c BSP_CMP.h BSP_GPIO.c BSP_GPIO.h BSP_ISR.c BSP_ISR.h BSP_OPA.c BSP_OPA.h BSP_PWM.c BSP_PWM.h BSP_TIM.c BSP_TIM.h BSP_USART.c BSP_USART.h BSP_WDG.c BSP_WDG.h
  group 1_HARDWARE/MCHAL
    1_HARDWARE/MCHAL/: MotorHal.h MotorHal_cfg.h
  group 2_COMMON/CMU
    ../../2_COMMON/CMU/: USART.c USART.h
  group 2_COMMON/MATH
    ../../2_COMMON/MATH/: Math.c Math.h Matrix.c Matrix.h
  group 2_COMMON/RTT
    ../../2_COMMON/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group 3_MOTOR
    ../3_MOTOR/: MotorPara.c MotorPara.h MotorSQ.c MotorSQ.h MotorTask.c MotorTask.h PmsmPara.h
  group 4_SYSTASK
    ../4_SYSTASK/: Button.c Button.h Current.c Current.h Error.c Error.h Speed.c Speed.h SysTask.c SysTask.h Temperature.c Temperature.h Voltage.c Voltage.h
  group 5_MAIN
    5_MAIN/: Main.c Main.h
