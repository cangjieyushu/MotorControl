# IAR project Z20K148M.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Z20K148M ZhiXin Z20K148M
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEV_Z20K148M; MCFOC_CJYS; MCFOC_CJYS_F; MCFOC_CJYS_1
  ICCARM.CCIncludePath2: ..\..\0_MCU\0_Z20K14xM\00_DEVICE\000_CORE; ..\..\0_MCU\0_Z20K14xM\00_DEVICE\001_INC; ..\..\0_MCU\0_Z20K14xM\00_DEVICE\002_MAKE; ..\..\0_MCU\0_Z20K14xM\00_DEVICE\003_START; ..\..\0_MCU\0_Z20K14xM\00_DEVICE\004_SYSTEM; ..\..\0_MCU\0_Z20K14xM\01_STD\010_INC; ..\..\0_MCU\0_Z20K14xM\01_STD\011_SRC; ..\..\1_HD\1_FOC1S_260101_Z20K14xM\10_HAL; ..\..\1_HD\1_FOC1S_260101_Z20K14xM\11_BSP; ..\..\1_HD\1_FOC1S_260101_Z20K14xM\12_MCH; ..\..\1_HD\1_FOC1S_260101_Z20K14xM\13_UARTH; ..\..\1_HD\1_FOC1S_260101_Z20K14xM\14_CANH; ..\..\2_COM\20_RTT; ..\..\2_COM\21_MATH; ..\..\2_COM\21_MATH\21_MATH_F; ..\..\2_COM\21_MATH\21_MATH_T; ..\..\2_COM\22_UARTS; ..\..\2_COM\23_CANS; ..\..\3_MC; ..\..\3_MC\31_FOC; ..\..\3_MC\31_FOC\310_FOC_F; ..\..\3_MC\31_FOC\311_FOC_T; ..\..\4_SYS; 5_MAIN; ..\..\2_COM\Z20A8300A\inc; ..\..\2_COM\Z20A8300A\src; Z20A8300A
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Z20K148M.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\0_MCU\0_Z20K14xM\00_DEVICE\002_MAKE\Z20K148M_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group 0_SDK/00_DEVICE
    ../../0_MCU/0_Z20K14xM/00_DEVICE/004_SYSTEM/: device_regs.h platform_cfg.h
    ../../0_MCU/0_Z20K14xM/00_DEVICE/001_INC/: Z20K148M.h
    ../../0_MCU/0_Z20K14xM/00_DEVICE/003_START/: Z20K148M_startup.s
  group 0_SDK/01_STD
    ../../0_MCU/0_Z20K14xM/01_STD/011_SRC/: adc_drv.c aes_drv.c can_drv.c clock_drv.c cmp_drv.c cmu_drv.c common_drv.c crc_drv.c dma_drv.c eiru_drv.c ewdt_drv.c flash_drv.c gpio_drv.c i2c_drv.c i2s_drv.c int_drv.c mcpwm_drv.c pmu_drv.c regfile_drv.c rtc_drv.c scm_drv.c seru_drv.c smpu_drv.c spi_drv.c srmc_drv.c stim_drv.c sysctrl_drv.c tdg_drv.c tim_drv.c tmu_drv.c trng_drv.c uart_drv.c wdog_drv.c
  group 1_HD/10_HAL
    ../../1_HD/1_FOC1S_260101_Z20K14xM/10_HAL/: HAL_CFG.h
  group 1_HD/11_BSP
    ../../1_HD/1_FOC1S_260101_Z20K14xM/11_BSP/: BSP.h BSP_ADC.c BSP_ADC.h BSP_CLK.c BSP_CLK.h BSP_DMA.c BSP_DMA.h BSP_GPIO.c BSP_GPIO.h BSP_ISR.c BSP_ISR.h BSP_PWM.c BSP_PWM.h BSP_TIM.c BSP_TIM.h BSP_TMU.c BSP_TMU.h BSP_USART.c BSP_USART.h BSP_WDG.c BSP_WDG.h
  group 1_HD/12_MCH
    ../../1_HD/1_FOC1S_260101_Z20K14xM/12_MCH/: MCH.h
  group 2_COM/20_RTT
    ../../2_COM/20_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group 2_COM/21_MATH
    ../../2_COM/21_MATH/: MATH.c MATH.h MATH_CHECK.c MATH_CHECK.h
    ../../2_COM/21_MATH/21_MATH_F/: MATH_ANGLE_F.c MATH_ANGLE_F.h MATH_LPF_F.c MATH_LPF_F.h MATH_PID_F.c MATH_PID_F.h MATH_RAMP_F.c MATH_RAMP_F.h MATH_TABLE_F.c MATH_TABLE_F.h
    ../../2_COM/21_MATH/21_MATH_T/: MATH_ANGLE_T.c MATH_ANGLE_T.h MATH_LPF_T.c MATH_LPF_T.h MATH_PID_T.c MATH_PID_T.h MATH_RAMP_T.c MATH_RAMP_T.h MATH_TABLE_T.c MATH_TABLE_T.h
  group 2_COM/22_UARTS
    ../../2_COM/22_UARTS/: UARTS.c UARTS.h
  group 2_COM/Z20A8300A
    ../../2_COM/Z20A8300A/src/: Z20A8300A_Config.c Z20A8300A_Ctrl.c Z20A8300A_Diag.c Z20A8300A_Spi.c
  group 3_MC
    ../../3_MC/: MC_ERR.c MC_ERR.h PMSM_PARA.h
  group 3_MC/310_MCFOC_F
    ../../3_MC/31_FOC/310_FOC_F/: MCFOC_API_F.c MCFOC_API_F.h MCFOC_EST_F.c MCFOC_EST_F.h MCFOC_LOOP_F.c MCFOC_LOOP_F.h MCFOC_PARA_F.c MCFOC_PARA_F.h MCFOC_PMSM_F.c MCFOC_PMSM_F.h MCFOC_SVPWM_F.c MCFOC_SVPWM_F.h MCFOC_TASK_F.c MCFOC_TASK_F.h
  group 3_MC/311_MCFOC_T
    ../../3_MC/31_FOC/311_FOC_T/: MCFOC_API_T.c MCFOC_API_T.h MCFOC_EST_T.c MCFOC_EST_T.h MCFOC_LOOP_T.c MCFOC_LOOP_T.h MCFOC_PARA_T.c MCFOC_PARA_T.h MCFOC_PMSM_T.c MCFOC_PMSM_T.h MCFOC_SVPWM_T.c MCFOC_SVPWM_T.h MCFOC_TASK_T.c MCFOC_TASK_T.h
  group 4_SYS
    ../../4_SYS/: BUTTON.c BUTTON.h SYS.h SYS_ERR.c SYS_ERR.h SYSTASK.c SYSTASK.h
  group 5_MAIN
    5_MAIN/: Main.c Main.h
  group 5_MAIN/Z20A8300A
    Z20A8300A/: Z20A8300A_Hal.c Z20A8300A_Hal.h Z20A8300A_Init.c Z20A8300A_Init.h
