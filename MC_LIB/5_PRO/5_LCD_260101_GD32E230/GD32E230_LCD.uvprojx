# Keil uVision project GD32E230_LCD.uvprojx, settings and files
target GD32E230_LCD (6160000::V6.16::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.3.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230_LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\..\0_COM\00_math;..\..\0_COM\00_math\000_math_f;..\..\0_COM\00_math\001_math_t;..\..\0_COM\01_RTT;..\..\1_MCU\1_GD32E230\10_device\100_core;..\..\1_MCU\1_GD32E230\10_device\101_inc;..\..\1_MCU\1_GD32E230\10_device\102_make;..\..\1_MCU\1_GD32E230\10_device\103_start;..\..\1_MCU\1_GD32E230\10_device\104_system;..\..\1_MCU\1_GD32E230\11_std\110_inc;..\..\1_MCU\1_GD32E230\11_std\111_src;..\..\2_HW\2_LCD_260101_GD32E230\20_hw;..\..\2_HW\2_LCD_260101_GD32E230\21_bsp;..\..\2_HW\2_LCD_260101_GD32E230\21_bsp\210_bsp_sys;..\..\2_HW\2_LCD_260101_GD32E230\21_bsp\211_bsp_mc;..\..\2_HW\2_LCD_260101_GD32E230\21_bsp\212_bsp_lcd;..\..\2_HW\2_LCD_260101_GD32E230\22_hal;..\..\3_MC;..\..\3_MC\32_sq;..\..\4_SYS;.\5_MAIN
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group 00_COM_MATH
    ../../0_COM/00_math/000_math_f/: math_angle_f.c math_angle_f.h math_filter_f.c math_filter_f.h math_pid_f.c math_pid_f.h math_ramp_f.c math_ramp_f.h math_table_f.c math_table_f.h
    ../../0_COM/00_math/001_math_t/: math_angle_t.c math_angle_t.h math_filter_t.c math_filter_t.h math_pid_t.c math_pid_t.h math_ramp_t.c math_ramp_t.h math_table_t.c math_table_t.h
    ../../0_COM/00_math/: math_check.c math_check.h math_type.c math_type.h
  group 01_COM_RTT
    ../../0_COM/01_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group 10_MCU_DEVICE
    ../../1_MCU/1_GD32E230/10_device/101_inc/: gd32e23x.h
    ../../1_MCU/1_GD32E230/10_device/103_start/: startup_gd32e23x.s
    ../../1_MCU/1_GD32E230/10_device/104_system/: system_gd32e23x.c system_gd32e23x.h
  group 11_MCU_STD
    ../../1_MCU/1_GD32E230/11_std/110_inc/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
    ../../1_MCU/1_GD32E230/11_std/111_src/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group 20_HW_HW
    ../../2_HW/2_LCD_260101_GD32E230/20_hw/: hw_fun.h hw_lcd.h hw_map.h hw_para.h
  group 210_BSP_SYS
    ../../2_HW/2_LCD_260101_GD32E230/21_bsp/: bsp.h
    ../../2_HW/2_LCD_260101_GD32E230/21_bsp/210_bsp_sys/: bsp_sys.c bsp_sys.h bsp_sys_clk.c bsp_sys_clk.h bsp_sys_dma.c bsp_sys_dma.h bsp_sys_gpio.c bsp_sys_gpio.h bsp_sys_isr.c bsp_sys_isr.h bsp_sys_uart.c bsp_sys_uart.h
  group 211_BSP_MC
    ../../2_HW/2_LCD_260101_GD32E230/21_bsp/211_bsp_mc/: bsp_mc.c bsp_mc.h bsp_mc_adc.c bsp_mc_adc.h bsp_mc_cmp.c bsp_mc_cmp.h bsp_mc_dac.c bsp_mc_dac.h bsp_mc_dma.c bsp_mc_dma.h bsp_mc_gpio.c bsp_mc_gpio.h bsp_mc_opamp.c bsp_mc_opamp.h bsp_mc_pwm.c bsp_mc_pwm.h bsp_mc_tim.c bsp_mc_tim.h
  group 212_BSP_LCD
    ../../2_HW/2_LCD_260101_GD32E230/21_bsp/212_bsp_lcd/: bsp_lcd.c bsp_lcd.h bsp_lcd_dma.c bsp_lcd_dma.h bsp_lcd_gpio.c bsp_lcd_gpio.h bsp_lcd_spi.c bsp_lcd_spi.h
  group 22_HW_HAL
    ../../2_HW/2_LCD_260101_GD32E230/22_hal/: hal_lcd.h hal_mc.h hal_uart.h
  group 30_MC_SQ
    ../../3_MC/: mc_api.c mc_api.h mc_error.c mc_error.h pmsm_para.h
    ../../3_MC/32_sq/: mcsq_ctrl.c mcsq_ctrl.h mcsq_para.c mcsq_para.h mcsq_task.c mcsq_task.h
  group 40_SYS
    ../../4_SYS/: sys_btn.c sys_btn.h sys_err.c sys_err.h sys_font.c sys_font.h sys_lcd.c sys_lcd.h sys_menu.c sys_menu.h sys_task.c sys_task.h sys_uart.c sys_uart.h
  group 5_MAIN
    ./5_MAIN/: main.c main.h
software components: CMSIS:CORE 5.5.0
