# Keil uVision project STM32F303_FOC.uvprojx, settings and files
target STM32F303_FOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303RBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32F303_FOC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F303xC, USE_STDPERIPH_DRIVER, __CC_ARM
  c include: ..\..\0_COM\00_math;..\..\0_COM\00_math\000_math_f;..\..\0_COM\00_math\001_math_t;..\..\0_COM\01_RTT;..\..\1_MCU\1_STM32F3\10_device\100_core;..\..\1_MCU\1_STM32F3\10_device\101_inc;..\..\1_MCU\1_STM32F3\10_device\102_make;..\..\1_MCU\1_STM32F3\10_device\103_start;..\..\1_MCU\1_STM32F3\10_device\104_system;..\..\1_MCU\1_STM32F3\11_std\110_inc;..\..\1_MCU\1_STM32F3\11_std\111_src;..\..\2_HW\2_FOC3S_260101_STM32F3\20_hw;..\..\2_HW\2_FOC3S_260101_STM32F3\21_bsp;..\..\2_HW\2_FOC3S_260101_STM32F3\21_bsp\210_bsp_sys;..\..\2_HW\2_FOC3S_260101_STM32F3\21_bsp\211_bsp_mc;..\..\2_HW\2_FOC3S_260101_STM32F3\21_bsp\212_bsp_lcd;..\..\2_HW\2_FOC3S_260101_STM32F3\22_hal;..\..\3_MC;..\..\3_MC\30_foc_f;..\..\3_MC\31_foc_t;..\..\4_SYS;.\5_MAIN
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group 00_COM_MATH
    ../../0_COM/00_math/000_math_f/: math_angle_f.c math_angle_f.h math_filter_f.c math_filter_f.h math_pid_f.c math_pid_f.h math_ramp_f.c math_ramp_f.h math_table_f.c math_table_f.h
    ../../0_COM/00_math/001_math_t/: math_angle_t.c math_angle_t.h math_filter_t.c math_filter_t.h math_pid_t.c math_pid_t.h math_ramp_t.c math_ramp_t.h math_table_t.c math_table_t.h
    ../../0_COM/00_math/: math_check.c math_check.h math_type.c math_type.h
  group 01_COM_RTT
    ../../0_COM/01_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group 10_MCU_DEVICE
    ../../1_MCU/1_STM32F3/10_device/101_inc/: stm32f30x.h
    ../../1_MCU/1_STM32F3/10_device/103_start/: startup_stm32f30x.s
    ../../1_MCU/1_STM32F3/10_device/104_system/: stm32f30x_conf.h system_stm32f30x.c system_stm32f30x.h
  group 11_MCU_STD
    ../../1_MCU/1_STM32F3/11_std/110_inc/: stm32f30x_adc.h stm32f30x_can.h stm32f30x_comp.h stm32f30x_crc.h stm32f30x_dac.h stm32f30x_dbgmcu.h stm32f30x_dma.h stm32f30x_exti.h stm32f30x_flash.h stm32f30x_fmc.h stm32f30x_gpio.h stm32f30x_hrtim.h stm32f30x_i2c.h stm32f30x_iwdg.h stm32f30x_misc.h stm32f30x_opamp.h stm32f30x_pwr.h stm32f30x_rcc.h stm32f30x_rtc.h stm32f30x_spi.h stm32f30x_syscfg.h stm32f30x_tim.h stm32f30x_usart.h stm32f30x_wwdg.h
    ../../1_MCU/1_STM32F3/11_std/111_src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group 20_HW_HW
    ../../2_HW/2_FOC3S_260101_STM32F3/20_hw/: hw_fun.h hw_lcd.h hw_map.h hw_para.h
  group 210_BSP_SYS
    ../../2_HW/2_FOC3S_260101_STM32F3/21_bsp/: bsp.h
    ../../2_HW/2_FOC3S_260101_STM32F3/21_bsp/210_bsp_sys/: bsp_sys.c bsp_sys.h bsp_sys_clk.c bsp_sys_clk.h bsp_sys_dma.c bsp_sys_dma.h bsp_sys_gpio.c bsp_sys_gpio.h bsp_sys_isr.c bsp_sys_isr.h bsp_sys_uart.c bsp_sys_uart.h
  group 211_BSP_MC
    ../../2_HW/2_FOC3S_260101_STM32F3/21_bsp/211_bsp_mc/: bsp_mc.c bsp_mc.h bsp_mc_adc.c bsp_mc_adc.h bsp_mc_cmp.c bsp_mc_cmp.h bsp_mc_dac.c bsp_mc_dac.h bsp_mc_dma.c bsp_mc_dma.h bsp_mc_gpio.c bsp_mc_gpio.h bsp_mc_opamp.c bsp_mc_opamp.h bsp_mc_pwm.c bsp_mc_pwm.h bsp_mc_tim.c bsp_mc_tim.h
  group 212_BSP_LCD
    ../../2_HW/2_FOC3S_260101_STM32F3/21_bsp/212_bsp_lcd/: bsp_lcd.c bsp_lcd.h bsp_lcd_dma.c bsp_lcd_dma.h bsp_lcd_gpio.c bsp_lcd_gpio.h bsp_lcd_spi.c bsp_lcd_spi.h
  group 22_HW_HAL
    ../../2_HW/2_FOC3S_260101_STM32F3/22_hal/: hal_lcd.h hal_mc.h hal_uart.h
  group 3_MC
    ../../3_MC/: mc_api.c mc_api.h mc_error.c mc_error.h pmsm_para.h
  group 30_MC_FOC_F
    ../../3_MC/30_foc_f/: mcfoc_est_f.c mcfoc_est_f.h mcfoc_loop_f.c mcfoc_loop_f.h mcfoc_para_f.c mcfoc_para_f.h mcfoc_pmsm_f.c mcfoc_pmsm_f.h mcfoc_svpwm_f.c mcfoc_svpwm_f.h mcfoc_task_f.c mcfoc_task_f.h
  group 31_MC_FOC_T
    ../../3_MC/31_foc_t/: mcfoc_est_t.c mcfoc_est_t.h mcfoc_loop_t.c mcfoc_loop_t.h mcfoc_para_t.c mcfoc_para_t.h mcfoc_pmsm_t.c mcfoc_pmsm_t.h mcfoc_svpwm_t.c mcfoc_svpwm_t.h mcfoc_task_t.c mcfoc_task_t.h
  group 40_SYS
    ../../4_SYS/: sys_btn.c sys_btn.h sys_err.c sys_err.h sys_font.c sys_font.h sys_lcd.c sys_lcd.h sys_menu.c sys_menu.h sys_task.c sys_task.h sys_uart.c sys_uart.h
  group 5_MAIN
    ./5_MAIN/: main.c main.h
