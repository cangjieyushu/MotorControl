# Keil uVision project STM32F407_FOC.uvprojx, settings and files
target STM32F407_FOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_FOC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, __CC_ARM
  c include: ..\..\0_COM\00_math;..\..\0_COM\00_math\000_math_f;..\..\0_COM\00_math\001_math_t;..\..\0_COM\01_RTT;..\..\1_MCU\1_STM32F4\10_device\100_core;..\..\1_MCU\1_STM32F4\10_device\101_inc;..\..\1_MCU\1_STM32F4\10_device\102_make;..\..\1_MCU\1_STM32F4\10_device\103_start;..\..\1_MCU\1_STM32F4\10_device\104_system;..\..\1_MCU\1_STM32F4\11_std\110_inc;..\..\1_MCU\1_STM32F4\11_std\111_src;..\..\2_HW\2_FOC3S_260101_STM32F4\20_hw;..\..\2_HW\2_FOC3S_260101_STM32F4\21_bsp;..\..\2_HW\2_FOC3S_260101_STM32F4\21_bsp\210_bsp_sys;..\..\2_HW\2_FOC3S_260101_STM32F4\21_bsp\211_bsp_mc;..\..\2_HW\2_FOC3S_260101_STM32F4\21_bsp\212_bsp_lcd;..\..\2_HW\2_FOC3S_260101_STM32F4\22_hal;..\..\3_MC;..\..\3_MC\30_foc_f;..\..\3_MC\31_foc_t;..\..\4_SYS;.\5_MAIN
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 00_COM_MATH
    ../../0_COM/00_math/000_math_f/: math_angle_f.c math_angle_f.h math_filter_f.c math_filter_f.h math_pid_f.c math_pid_f.h math_ramp_f.c math_ramp_f.h math_table_f.c math_table_f.h
    ../../0_COM/00_math/001_math_t/: math_angle_t.c math_angle_t.h math_filter_t.c math_filter_t.h math_pid_t.c math_pid_t.h math_ramp_t.c math_ramp_t.h math_table_t.c math_table_t.h
    ../../0_COM/00_math/: math_check.c math_check.h math_type.c math_type.h
  group 01_COM_RTT
    ../../0_COM/01_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group 10_MCU_DEVICE
    ../../1_MCU/1_STM32F4/10_device/101_inc/: stm32f4xx.h
    ../../1_MCU/1_STM32F4/10_device/103_start/: startup_stm32f40_41xxx.s
    ../../1_MCU/1_STM32F4/10_device/104_system/: stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group 11_MCU_STD
    ../../1_MCU/1_STM32F4/11_std/111_src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group 20_HW_HW
    ../../2_HW/2_FOC3S_260101_STM32F4/20_hw/: hw_fun.h hw_lcd.h hw_map.h hw_para.h
  group 210_BSP_SYS
    ../../2_HW/2_FOC3S_260101_STM32F4/21_bsp/: bsp.h
    ../../2_HW/2_FOC3S_260101_STM32F4/21_bsp/210_bsp_sys/: bsp_sys.c bsp_sys.h bsp_sys_clk.c bsp_sys_clk.h bsp_sys_dma.c bsp_sys_dma.h bsp_sys_gpio.c bsp_sys_gpio.h bsp_sys_isr.c bsp_sys_isr.h bsp_sys_uart.c bsp_sys_uart.h
  group 211_BSP_MC
    ../../2_HW/2_FOC3S_260101_STM32F4/21_bsp/211_bsp_mc/: bsp_mc.c bsp_mc.h bsp_mc_adc.c bsp_mc_adc.h bsp_mc_cmp.c bsp_mc_cmp.h bsp_mc_dac.c bsp_mc_dac.h bsp_mc_dma.c bsp_mc_dma.h bsp_mc_gpio.c bsp_mc_gpio.h bsp_mc_opamp.c bsp_mc_opamp.h bsp_mc_pwm.c bsp_mc_pwm.h bsp_mc_tim.c bsp_mc_tim.h
  group 212_BSP_LCD
    ../../2_HW/2_FOC3S_260101_STM32F4/21_bsp/212_bsp_lcd/: bsp_lcd.c bsp_lcd.h bsp_lcd_dma.c bsp_lcd_dma.h bsp_lcd_gpio.c bsp_lcd_gpio.h bsp_lcd_spi.c bsp_lcd_spi.h
  group 22_HW_HAL
    ../../2_HW/2_FOC3S_260101_STM32F4/22_hal/: hal_lcd.h hal_mc.h hal_uart.h
  group 3_MC
    ../../3_MC/: mc_api.c mc_api.h mc_error.c mc_error.h pmsm_para.h
  group 30_MC_FOC_F
    ../../3_MC/30_foc_f/: mcfoc_est_f.c mcfoc_est_f.h mcfoc_loop_f.c mcfoc_loop_f.h mcfoc_para_f.c mcfoc_para_f.h mcfoc_pmsm_f.c mcfoc_pmsm_f.h mcfoc_svpwm_f.c mcfoc_svpwm_f.h mcfoc_task_f.c mcfoc_task_f.h
  group 31_MC_FOC_T
    ../../3_MC/31_foc_t/: mcfoc_est_t.c mcfoc_est_t.h mcfoc_loop_t.c mcfoc_loop_t.h mcfoc_para_t.c mcfoc_para_t.h mcfoc_pmsm_t.c mcfoc_pmsm_t.h mcfoc_svpwm_t.c mcfoc_svpwm_t.h mcfoc_task_t.c mcfoc_task_t.h
  group 40_SYS
    ../../4_SYS/: sys_btn.c sys_btn.h sys_err.c sys_err.h sys_font.c sys_font.h sys_lcd.c sys_lcd.h sys_menu.c sys_menu.h sys_task.c sys_task.h sys_uart.c sys_uart.h
  group 5_MAIN
    ./5_MAIN/: main.c main.h
