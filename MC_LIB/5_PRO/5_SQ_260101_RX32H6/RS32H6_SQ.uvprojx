# Keil uVision project RS32H6_SQ.uvprojx, settings and files
target RS32H6_SQ (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: RX32H6 ICORE
  pack: Keil.RX32H6_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RS32H6_SQ +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\0_COM\00_math;..\..\0_COM\00_math\000_math_f;..\..\0_COM\00_math\001_math_t;..\..\0_COM\01_RTT;..\..\1_MCU\1_RX32H6\10_device\100_core;..\..\1_MCU\1_RX32H6\10_device\101_inc;..\..\1_MCU\1_RX32H6\10_device\102_make;..\..\1_MCU\1_RX32H6\10_device\103_start;..\..\1_MCU\1_RX32H6\10_device\104_system;..\..\1_MCU\1_RX32H6\11_std\110_inc;..\..\1_MCU\1_RX32H6\11_std\111_src;..\..\2_HW\2_SQ_260101_RX32H6\20_hw;..\..\2_HW\2_SQ_260101_RX32H6\21_bsp;..\..\2_HW\2_SQ_260101_RX32H6\22_hal;..\..\3_MC;..\..\3_MC\32_sq;..\..\4_SYS;.\5_MAIN
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group 00_COM_MATH
    ../../0_COM/00_math/000_math_f/: math_angle_f.c math_angle_f.h math_filter_f.c math_filter_f.h math_pid_f.c math_pid_f.h math_ramp_f.c math_ramp_f.h math_table_f.c math_table_f.h
    ../../0_COM/00_math/001_math_t/: math_angle_t.c math_angle_t.h math_filter_t.c math_filter_t.h math_pid_t.c math_pid_t.h math_ramp_t.c math_ramp_t.h math_table_t.c math_table_t.h
    ../../0_COM/00_math/: math_check.c math_check.h math_type.c math_type.h
  group 01_COM_RTT
    ../../0_COM/01_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group 10_MCU_DEVICE
    ../../1_MCU/1_RX32H6/10_device/101_inc/: rx32h6xx.h
    ../../1_MCU/1_RX32H6/10_device/103_start/: startup_rx32h6xx.s
    ../../1_MCU/1_RX32H6/10_device/104_system/: system_rx32h6xx.c system_rx32h6xx.h
  group 11_MCU_STD
    ../../1_MCU/1_RX32H6/11_std/110_inc/: rx32h6xx_adc.h rx32h6xx_cmp.h rx32h6xx_cortex.h rx32h6xx_crc.h rx32h6xx_dbg.h rx32h6xx_exti.h rx32h6xx_flash.h rx32h6xx_gpio.h rx32h6xx_i2c.h rx32h6xx_iwdg.h rx32h6xx_me.h rx32h6xx_opamp.h rx32h6xx_pwr.h rx32h6xx_rcc.h rx32h6xx_rtc.h rx32h6xx_spi.h rx32h6xx_tim.h rx32h6xx_usart.h rx32h6xx_vrefbuf.h
    ../../1_MCU/1_RX32H6/11_std/111_src/: rx32h6xx_adc.c rx32h6xx_cmp.c rx32h6xx_crc.c rx32h6xx_exti.c rx32h6xx_flash.c rx32h6xx_gpio.c rx32h6xx_i2c.c rx32h6xx_iwdg.c rx32h6xx_me.c rx32h6xx_opamp.c rx32h6xx_pwr.c rx32h6xx_rcc.c rx32h6xx_rtc.c rx32h6xx_spi.c rx32h6xx_tim.c rx32h6xx_usart.c
  group 20_HW_HW
    ../../2_HW/2_SQ_260101_RX32H6/20_hw/: hw_clk.h hw_map.h hw_para.h
  group 21_HW_BSP
    ../../2_HW/2_SQ_260101_RX32H6/21_bsp/: bsp.h bsp_adc.c bsp_adc.h bsp_clk.c bsp_clk.h bsp_cmp.c bsp_cmp.h bsp_gpio.c bsp_gpio.h bsp_isr.c bsp_isr.h bsp_opa.c bsp_opa.h bsp_pwm.c bsp_pwm.h bsp_tim.c bsp_tim.h bsp_uart.c bsp_uart.h
  group 22_HW_HAL
    ../../2_HW/2_SQ_260101_RX32H6/22_hal/: hal_mc.h
  group 30_MCSQ
    ../../3_MC/: mc_api.c mc_api.h mc_error.c mc_error.h pmsm_para.h
    ../../3_MC/32_sq/: mcsq_ctrl.c mcsq_ctrl.h mcsq_para.c mcsq_para.h mcsq_task.c mcsq_task.h
  group 40_SYS
    ../../4_SYS/: sys_btn.c sys_btn.h sys_err.c sys_err.h sys_task.c sys_task.h
  group 5_MAIN
    ./5_MAIN/: main.c main.h
